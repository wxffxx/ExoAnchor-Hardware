# Repository wxffxx/ExoAnchor-Hardware (continued)

## KiCad design ESP32P4/exoanchor-p4-v2.3b6/KiCad/ExoAnchor_P4_V2.3B6.kicad_pcb (continued)

Parts:
C2, C14: 100nF; C0402__aba8f707; Tolerance ±10%; Voltage Rating 16V; Manufacturer Part CL05B104KO5NNNC; LCSC Part Name 100nF ±10% 16V
C15, C16: 20pF; C0603__a4480e4e; Tolerance ±5%; Voltage Rating 50V; Manufacturer Part CL10C200JB8NNNC; LCSC Part Name 20pF ±5% 50V
C43, C44: 10uF; C0805__eb27e37a; Tolerance ±10%; Voltage Rating 25V; Manufacturer Part CL21A106KAYNNNE; LCSC Part Name 10uF ±10% 25V
C45, C46, C47, C48, C49, C50, C51, C52, C53, C55, C56, C57, C58, C60, C62, C63, C65, C67: 100nF; C0402 去耦电容__92f207f8; Tolerance ±10%; Voltage Rating 16V; Manufacturer Part CL05B104KO5NNNC; LCSC Part Name 100nF ±10% 16V
C54: 10uF; C0603__a4480e4e; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part CL10A106MA8NRNC; LCSC Part Name 10uF ±20% 25V
C59, C61, C64: 1uF; C0402__aba8f707; Tolerance ±10%; Voltage Rating 25V; Manufacturer Part CL05A105KA5NQNC; LCSC Part Name 1uF ±10% 25V
C66: 10uF; C0402__aba8f707; Tolerance ±20%; Voltage Rating 10V; Manufacturer Part HGC0402R5106M100NTEJ; LCSC Part Name 10uF ±20% 10V
C109: 10uF; C0805__eb27e37a; Tolerance ±10%; Voltage Rated 25V; Manufacturer Part CL21A106KAYNNNE; LCSC Part Name 10uF ±10% 25V
Locate_Led1: GL0603UR01; LED0603-FD__402ba6a9; Voltage - Forward(Vf) 2.4V; Manufacturer Part GL0603UR01; LCSC Part Name 0603 红灯 高亮
R15, R18, R19, R25: 10kΩ; R0402__b4a31b25; Tolerance ±1%; Voltage-Supply(Max) 50V; Manufacturer Part FRC0402F1002TS; LCSC Part Name 10kΩ ±1% 62.5mW 厚膜电阻
R26: 10kΩ; R0603__0f1821c5; Tolerance ±1%; Voltage-Supply(Max) 75V; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R28: 22Ω; R0402__b4a31b25; Overload Voltage (Max) 50V; Tolerance ±1%; Manufacturer Part 0402WGF220JTCE; LCSC Part Name 22Ω ±1% 62.5mW 厚膜电阻
R29, R30: 4.02kΩ; R0402__b4a31b25; Tolerance ±1%; Voltage-Supply(Max) 50V; Manufacturer Part RMC04024.02K1%N; LCSC Part Name 4.02kΩ ±1% 62.5mW
R31, R61: 0R; R0402__b4a31b25
R48: 1kΩ; R0603__0f1821c5; Overload Voltage (Max) 75V; Tolerance ±1%; Manufacturer Part 0603WAF1001T5E; LCSC Part Name 1kΩ ±1% 100mW 厚膜电阻
U4: GD5F2GQ5UEYIGR; WSON-8_L6.0-W8.0-P1.27-BL-EP__e8e18484; Manufacturer Part GD5F2GQ5UEYIGR; LCSC Part Name 2Gbit SPI NAND 3.3V
U13: ESP32-P4NRW32X; QFN-104_L10.0-W10.0-P0.35-TL-EP7.5__563c2754; Manufacturer Part ESP32-P4NRW32; LCSC Part Name 不带固件 搭载RISC-V32位双核与单核处理器的高性能MCU，具备强大图像与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
U22: GD25Q128EWIGR; WSON-8_L6.0-W5.0-P1.27-TL-EP__330bd00a; Manufacturer Part GD25Q128EWIGR; LCSC Part Name 双路和四路串行闪存
U23: ZX-SH1.0-3PLT; CONN-SMD_3P-P1.00_HDGC_HDGC1002WV-S-3P__7ddb6fe6; Manufacturer Part ZX-SH1.0-3PLT; LCSC Part Name 1x3P 间距:1mm 立贴 系列:SH
X2: 40MHz; OSC-SMD_4P-L3.2-W2.5-BL_SIT8008BI__8f1a8610; Manufacturer Part X322540MPB4SI; LCSC Part Name YSX321SL 40MHZ 4P 3225 15PF ±10PPM -40~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

Connections:
3V3_SYS: C2.1, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C109.2, R15.1, R18.1, R19.2, R26.2, U4.8 (VCC), U13.9 (VDD_LP), U13.21 (VDD_IO_0), U13.51 (VDD_USBPHY), U13.62 (VDD_IO_4), U13.75 (VDD_LDO), U13.77 (VDD_DCDCC), U13.96 (VDD_IO_6), U13.101 (VDD_ANA), U13.102 (VDD_BAT); also elsewhere on the board
$10N53: R28.2, U13.32 (FLASH_CK)
$10N190: Locate_Led1.1 (A), R48.2
CH343P0_USB_RXD: U13.69 (GPIO37); also elsewhere on the board
CH343P0_USB_TXD: U13.70 (GPIO38); also elsewhere on the board
CHIP_PU: U13.103 (CHIP_PU); also elsewhere on the board
CSI_REXT: R30.2, U13.48 (CSI_REXT)
DM_HID: U13.55 (GPIO26); also elsewhere on the board
DM_MS: U13.49 (DM); also elsewhere on the board
DP_HID: U13.56 (GPIO27); also elsewhere on the board
DP_MS: U13.50 (DP); also elsewhere on the board
DSI_REXT: R29.2, U13.34 (DSI_REXT)
EMMC_CLK: U13.84 (GPIO43); also elsewhere on the board
EMMC_CMD: U13.86 (GPIO44); also elsewhere on the board
EMMC_D0: U13.80 (GPIO39); also elsewhere on the board
EMMC_D1: U13.81 (GPIO40); also elsewhere on the board
EMMC_D2: U13.82 (GPIO41); also elsewhere on the board
EMMC_D3: U13.83 (GPIO42); also elsewhere on the board
EMMC_D4: U13.87 (GPIO45)
EMMC_D5: U13.88 (GPIO46)
ESP32P4_EN_DCDC: U13.79 (EN_DCDC); also elsewhere on the board
ESP32P4_FB_DCDC: U13.78 (FB_DCDC); also elsewhere on the board
ETH_INT_PWDN: U13.25 (GPIO23); also elsewhere on the board
ETH_LED_GPIO15: U13.16 (GPIO15); also elsewhere on the board
ETH_RST_N: U13.24 (GPIO22); also elsewhere on the board
GND: C2.2, C14.2, C15.2, C16.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C109.1, Locate_Led1.2 (C), R29.1, R30.1, U4.4 (VSS), U4.9 (EP), U13.105 (GND), U22.4 (VSS), U22.9 (EP), U23.3, U23.4, U23.5, X2.2 (GND), X2.4 (GND); also elsewhere on the board
GPIO0: U13.104 (GPIO0); also elsewhere on the board
GPIO1: U13.1 (GPIO1); also elsewhere on the board
GPIO2: U13.2 (GPIO2); also elsewhere on the board
GPIO3: U13.3 (GPIO3); also elsewhere on the board
GPIO4: U13.4 (GPIO4); also elsewhere on the board
GPIO5: U13.5 (GPIO5); also elsewhere on the board
GPIO16: U13.17 (GPIO16); also elsewhere on the board
GPIO17: R48.1, U13.18 (GPIO17)
GPIO18: U13.19 (GPIO18)
GPIO36: R26.1, U13.68 (GPIO36)
GPIO49: U13.92 (GPIO49)
MDC: U13.22 (GPIO20); also elsewhere on the board
MDIO: U13.23 (GPIO21); also elsewhere on the board
MS_SCL: R31.1; also elsewhere on the board
MS_SDA: R61.1; also elsewhere on the board
P4_FLASH_CK: R28.1, U22.6 (SCLK)
P4_FLASH_CS: R25.2, U13.27 (FLASH_CS), U22.1 (CS#)
P4_FLASH_D: U13.33 (FLASH_D), U22.5 (SI(IO0))
P4_FLASH_HOLD: U13.31 (FLASH_HOLD), U22.7 (HOLD#/RESET#(IO3))
P4_FLASH_Q: U13.28 (FLASH_Q), U22.2 (SO(IO1))
P4_FLASH_WP: U13.29 (FLASH_WP), U22.3 (WP#(IO2))
P4_VDDO1_FLASH: C14.1, C59.2, C60.2, R25.1, U13.30 (VDD_FLASHIO), U13.71 (VDDO_FLASH), U22.8 (VCC)
P4_VDDO2_PSRAM: C61.2, C62.2, C63.2, U13.59 (VDD_PSRAM_0), U13.67 (VDD_PSRAM_1), U13.72 (VDDO_PSRAM)
P4_VDDO3_MIPI: C64.2, C65.2, U13.41 (VDD_MIPI_DPHY), U13.73 (VDDO_3)
P4_VDDO4_SDIO: C66.2, C67.2, U13.74 (VDDO_4), U13.85 (VDD_IO_5); also elsewhere on the board
P4_XTAL_N: C15.1, U13.99 (XTAL_N), X2.3 (OSC2)
P4_XTAL_P: C16.2, U13.100 (XTAL_P), X2.1 (OSC1)
RMII_CLK: U13.63 (GPIO32); also elsewhere on the board
RMII_CRS_DV: U13.57 (GPIO28); also elsewhere on the board
RMII_RXD0: U13.58 (GPIO29); also elsewhere on the board
RMII_RXD1: U13.60 (GPIO30); also elsewhere on the board
RMII_RX_ER_GPIO31: U13.61 (GPIO31); also elsewhere on the board
RMII_TXD0: U13.65 (GPIO34); also elsewhere on the board
RMII_TXD1_GPIO35: U13.66 (GPIO35); also elsewhere on the board
RMII_TX_EN: U13.64 (GPIO33); also elsewhere on the board
SCL: R31.2, U13.89 (GPIO47)
SDA: R61.2, U13.90 (GPIO48)
SPI1_CLK_GPIO9: U4.6 (SCLK), U13.10 (GPIO9)
SPI1_CS_GPIO7: R15.2, U4.1 (CS#), U13.7 (GPIO7)
SPI1_IO0_GPIO8: U4.5 (SI/SIO0), U13.8 (GPIO8)
SPI1_IO1_GPIO10: U4.2 (SO/SIO1), U13.11 (GPIO10)
SPI1_IO2_GPIO11: R18.2, U4.3 (WP#/SIO2), U13.12 (GPIO11)
SPI1_IO3_GPIO6: R19.1, U4.7 (HOLD#/SIO3), U13.6 (GPIO6)
USB1P1_N0: U13.52 (GPIO24), U23.1
USB1P1_P0: U13.53 (GPIO25), U23.2
VCC_HP: C54.2, C55.2, C56.2, C57.2, C58.2, U13.26 (VDD_HP_0), U13.54 (VDD_HP_1), U13.76 (VDD_HP_2), U13.91 (VDD_HP_3); also elsewhere on the board

Notes on the sheet:
VDD_HP_0/1/2/3: 每脚 100nF，附近再放 10uF VDD_DCDCC: 10uF + 100nF VDD_LDO: 10uF + 100nF VDD_ANA: 1uF + 100nF VDD_BAT: 1uF VDD_USBPHY: 1uF + 100nF VDDO_FLASH: 1uF + 100nF VDDO_PSRAM: 1uF + 100nF VDDO_3: 1uF VDDO_4: 1uF，VDD_IO_5 旁边再放 10uF

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
Board: 6 copper layers, 183.6 x 143.8 mm, 185 parts (0 on the bottom side), 136 nets.

## Commit log (part)

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2026-06-26 Add ExoAnchor hardware files
